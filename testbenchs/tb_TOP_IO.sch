v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -60 540 740 940 {flags=graph
y1=-0.014
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=8.6679914e-09
x2=8.9571161e-09
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=0.5
divx=20
color="7 12 18 11"
node="cpout
out_a
in_c
vcont"}
B 2 1370 370 2170 770 {flags=graph
y1=-0.4198089
y2=1.6533911
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=8.6679914e-09
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="6 21 7 11"
node="in_a
vin
vout
out_a"
linewidth_mult=0.5
divx=20
hilight_wave=0
x2=8.9571161e-09}
N -360 -450 -360 -440 {
lab=IO_vdd}
N -300 -450 -300 -440 {
lab=IO_iovdd}
N -440 -450 -440 -440 {
lab=IO_vss}
N -500 -450 -500 -440 {
lab=IO_iovss}
N 580 70 600 70 {lab=out_a}
N 20 -260 240 -260 {lab=IO_vdd}
N -210 -280 260 -280 {lab=IO_iovss}
N -220 210 270 210 {lab=IO_iovdd}
N 240 -60 300 -60 {lab=IO_vdd}
N 250 -70 300 -70 {lab=IO_vss}
N 260 -110 300 -110 {lab=IO_iovss}
N 270 -120 300 -120 {lab=IO_iovdd}
N 240 20 300 20 {lab=IO_vdd}
N 240 -60 240 20 {lab=IO_vdd}
N 250 10 300 10 {lab=IO_vss}
N 250 -70 250 10 {lab=IO_vss}
N 260 -30 300 -30 {lab=IO_iovss}
N 260 -110 260 -30 {lab=IO_iovss}
N 270 -40 300 -40 {lab=IO_iovdd}
N 270 -90 270 -40 {lab=IO_iovdd}
N 240 40 240 180 {lab=IO_vdd}
N 250 50 250 190 {lab=IO_vss}
N 260 90 260 200 {lab=IO_iovss}
N 270 100 270 210 {lab=IO_iovdd}
N -220 -120 -220 -40 {lab=IO_iovdd}
N 580 -90 600 -90 {lab=IO_iovdd}
N 270 -120 270 -90 {lab=IO_iovdd}
N 580 -10 600 -10 {lab=IO_iovss}
N 260 -30 260 -10 {lab=IO_iovss}
N 540 -120 540 -90 {lab=IO_iovdd}
N 270 -90 540 -90 {lab=IO_iovdd}
N 540 -50 540 -10 {lab=IO_iovss}
N 260 -10 540 -10 {lab=IO_iovss}
N -190 100 -190 180 {lab=IO_vdd}
N -200 170 -200 190 {lab=IO_vss}
N -210 130 -210 200 {lab=IO_iovss}
N -220 120 -220 210 {lab=IO_iovdd}
N -560 -40 -560 -10 {lab=IO_vss}
N -560 -130 -560 -90 {lab=IO_vdd}
N -260 -120 -220 -120 {lab=IO_iovdd}
N -220 -200 -220 -120 {lab=IO_iovdd}
N -260 -110 -210 -110 {lab=IO_iovss}
N -210 -190 -210 -110 {lab=IO_iovss}
N -260 -70 -200 -70 {lab=IO_vss}
N -260 -60 -190 -60 {lab=IO_vdd}
N -190 -90 -190 -60 {lab=IO_vdd}
N -260 -40 -220 -40 {lab=IO_iovdd}
N -260 -30 -210 -30 {lab=IO_iovss}
N -210 -110 -210 -30 {lab=IO_iovss}
N -260 10 -200 10 {lab=IO_vss}
N -200 -10 -200 10 {lab=IO_vss}
N -260 20 -190 20 {lab=IO_vdd}
N -190 -60 -190 20 {lab=IO_vdd}
N -510 -10 -200 -10 {lab=IO_vss}
N -600 -10 -560 -10 {lab=IO_vss}
N -200 -70 -200 -10 {lab=IO_vss}
N -600 -90 -560 -90 {lab=IO_vdd}
N -510 -90 -190 -90 {lab=IO_vdd}
N -260 40 -220 40 {lab=IO_iovdd}
N -220 -40 -220 40 {lab=IO_iovdd}
N -260 50 -210 50 {lab=IO_iovss}
N -210 -30 -210 50 {lab=IO_iovss}
N -260 90 -200 90 {lab=IO_vss}
N -200 10 -200 90 {lab=IO_vss}
N -260 100 -190 100 {lab=IO_vdd}
N -190 20 -190 100 {lab=IO_vdd}
N -560 70 -500 70 {lab=in_b}
N -600 70 -560 70 {lab=in_b}
N -190 180 240 180 {lab=IO_vdd}
N -190 -140 -190 -90 {lab=IO_vdd}
N -260 -150 -200 -150 {lab=IO_vss}
N -200 -150 -200 -70 {lab=IO_vss}
N -200 -270 -200 -150 {lab=IO_vss}
N -260 -190 -210 -190 {lab=IO_iovss}
N -210 -280 -210 -190 {lab=IO_iovss}
N -260 -200 -220 -200 {lab=IO_iovdd}
N -220 -290 -220 -200 {lab=IO_iovdd}
N -200 -270 250 -270 {lab=IO_vss}
N -560 -170 -500 -170 {lab=in_a}
N -560 -190 -560 -170 {lab=in_a}
N -600 -170 -560 -170 {lab=in_a}
N -260 -140 -190 -140 {lab=IO_vdd}
N -190 -260 -190 -140 {lab=IO_vdd}
N -40 -430 -20 -430 {lab=GND}
N -20 -430 -20 -420 {lab=GND}
N -120 -430 -100 -430 {lab=sub!}
N -120 -430 -120 -420 {lab=sub!}
N 20 190 250 190 {lab=IO_vss}
N -560 40 -560 70 {lab=in_b}
N 630 -250 660 -250 {lab=out_a}
N 780 -180 780 -140 {lab=out_a}
N 820 -180 850 -180 {lab=out_a}
N 850 -180 850 -140 {lab=out_a}
N 820 -210 820 -180 {lab=out_a}
N 780 -180 820 -180 {lab=out_a}
N 270 100 300 100 {lab=IO_iovdd}
N 270 -40 270 100 {lab=IO_iovdd}
N 260 90 300 90 {lab=IO_iovss}
N 260 -10 260 90 {lab=IO_iovss}
N 250 50 300 50 {lab=IO_vss}
N 250 10 250 50 {lab=IO_vss}
N 240 40 300 40 {lab=IO_vdd}
N 240 20 240 40 {lab=IO_vdd}
N -150 -50 -130 -50 {lab=vout}
N -260 -170 -150 -170 {lab=vin}
N -220 -290 270 -290 {lab=IO_iovdd}
N -210 200 260 200 {lab=IO_iovss}
N 170 -70 200 -70 {lab=vout}
N -800 20 -800 40 {lab=GND}
N -600 150 -560 150 {lab=in_c}
N -560 120 -560 150 {lab=in_c}
N -560 150 -500 150 {lab=in_c}
N -560 150 -560 320 {lab=in_c}
N 580 70 580 320 {lab=out_a}
N 540 70 580 70 {lab=out_a}
N 850 -180 930 -180 {lab=out_a}
N 990 -180 1100 -180 {lab=in_b}
N 1100 -200 1100 -180 {lab=in_b}
N -560 320 -20 320 {lab=in_c}
N 40 320 580 320 {lab=out_a}
N -150 -190 -150 -170 {lab=vin}
N -260 120 -220 120 {lab=IO_iovdd}
N -220 40 -220 120 {lab=IO_iovdd}
N -260 130 -210 130 {lab=IO_iovss}
N -210 50 -210 130 {lab=IO_iovss}
N -260 170 -200 170 {lab=IO_vss}
N -200 90 -200 170 {lab=IO_vss}
N -260 180 -190 180 {lab=IO_vdd}
N -150 -170 -150 -90 {lab=vin}
N -150 -90 -130 -90 {lab=vin}
N -800 -70 -800 -40 {lab=#net1}
N -800 -160 -800 -130 {lab=in_a}
N -510 -90 -510 -80 {lab=IO_vdd}
N -560 -90 -510 -90 {lab=IO_vdd}
N -510 -20 -510 -10 {lab=IO_vss}
N -560 -10 -510 -10 {lab=IO_vss}
N 580 -90 580 -80 {lab=IO_iovdd}
N 540 -90 580 -90 {lab=IO_iovdd}
N 580 -20 580 -10 {lab=IO_iovss}
N 540 -10 580 -10 {lab=IO_iovss}
N 20 -260 20 -130 {lab=IO_vdd}
N -190 -260 20 -260 {lab=IO_vdd}
N 20 -10 20 190 {lab=IO_vss}
N -200 190 20 190 {lab=IO_vss}
N 240 -140 240 -60 {lab=IO_vdd}
N 250 -150 250 -70 {lab=IO_vss}
N 260 -190 260 -110 {lab=IO_iovss}
N 270 -200 270 -120 {lab=IO_iovdd}
N 630 -280 630 -250 {lab=out_a}
N 600 -250 630 -250 {lab=out_a}
N 200 -170 200 -70 {lab=vout}
N 600 -250 600 -170 {lab=out_a}
N -150 -50 -150 100 {lab=vout}
N 200 -70 200 100 {lab=vout}
N 90 -10 90 70 {lab=vcont}
N -40 70 90 70 {lab=vcont}
N -40 -10 -40 70 {lab=vcont}
N 200 -170 300 -170 {lab=vout}
N 200 -180 200 -170 {lab=vout}
N 270 -200 300 -200 {lab=IO_iovdd}
N 270 -290 270 -200 {lab=IO_iovdd}
N 260 -190 300 -190 {lab=IO_iovss}
N 260 -280 260 -190 {lab=IO_iovss}
N 250 -150 300 -150 {lab=IO_vss}
N 250 -270 250 -150 {lab=IO_vss}
N 240 -140 300 -140 {lab=IO_vdd}
N 240 -260 240 -140 {lab=IO_vdd}
N 540 -170 600 -170 {lab=out_a}
N -150 100 200 100 {lab=vout}
N -260 70 -120 70 {lab=vpb}
C {vsource.sym} -360 -410 0 0 {name=V1 value=1.2}
C {gnd.sym} -360 -380 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -360 -450 1 0 {name=p7 sig_type=std_logic lab=IO_vdd}
C {vsource.sym} -300 -410 0 0 {name=V2 value=3.3
}
C {gnd.sym} -300 -380 0 0 {name=l4 lab=GND}
C {lab_pin.sym} -300 -450 1 0 {name=p8 sig_type=std_logic lab=IO_iovdd}
C {vsource.sym} -440 -410 0 0 {name=V3 value=0 savecurrent=false}
C {gnd.sym} -440 -380 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -440 -450 1 0 {name=p9 sig_type=std_logic lab=IO_vss}
C {vsource.sym} -500 -410 0 0 {name=V4 value=0 savecurrent=false}
C {gnd.sym} -500 -380 0 0 {name=l6 lab=GND}
C {lab_pin.sym} -500 -450 1 0 {name=p10 sig_type=std_logic lab=IO_iovss}
C {devices/code_shown.sym} -1530 -480 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.include diodes.lib
.include sg13g2_bondpad.lib
.include /foss/pdks/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
"}
C {devices/code_shown.sym} -1540 -250 0 0 {name=NGSPICE only_toplevel=true 
value="
.param temp=27
*.OPTION RSHUNT=1e6
.OPTION CSHUNT=1e-13
.option rseries = 10.0e-0
.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
*.options reltol=1e-4 abstol=1e-12 vntol=1e-6
*.options gmin=1e-10
*.ic V(out)=0

.control
save all 



tran 30p 10n






write power_io.raw


.endc
"
spice_ignore=true}
C {lab_pin.sym} 540 -120 2 0 {name=p3 sig_type=std_logic lab=IO_iovdd}
C {lab_pin.sym} 540 -50 2 0 {name=p4 sig_type=std_logic lab=IO_iovss}
C {lab_pin.sym} -560 -130 0 1 {name=p5 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} -560 -40 2 0 {name=p6 sig_type=std_logic lab=IO_vss}
C {sg13g2_IOPadIOVdd.sym} 420 -90 0 0 {name=x1}
C {sg13g2_IOPadIOVss.sym} 420 -10 0 0 {name=x3}
C {sg13g2_IOPadVSS.sym} -380 -10 0 1 {name=x2}
C {sg13g2_IOPadVdd.sym} -380 -90 0 1 {name=x4}
C {sg13g2_pr/bondpad.sym} 640 -10 1 0 {name=X6
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 640 -90 1 0 {name=X7
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -640 -90 3 1 {name=X8
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -640 -10 3 1 {name=X9
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 640 70 1 0 {name=X10
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {devices/launcher.sym} -840 970 0 0 {name=h5
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/power_io.raw tran"
}
C {sg13g2_pr/bondpad.sym} -640 70 3 1 {name=X12
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_IOPadAnalog.sym} -380 -170 0 1 {name=x13}
C {sg13g2_pr/bondpad.sym} -640 -170 3 1 {name=X14
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {gnd.sym} -800 40 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -800 -160 1 0 {name=p11 sig_type=std_logic lab=in_a}
C {lab_pin.sym} -560 -190 1 0 {name=p1 sig_type=std_logic lab=in_a}
C {sg13g2_pr/sub.sym} -120 -420 0 0 {name=l8 lab=sub!}
C {gnd.sym} -20 -420 0 0 {name=l11 lab=GND}
C {vsource.sym} -70 -430 1 0 {name=V5 value=0 savecurrent=false}
C {sg13g2_pr/bondpad.sym} 700 -250 1 0 {name=X16
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {capa.sym} 780 -110 0 0 {name=C5
m=1
value=100f
footprint=1206
device="ceramic capacitor"
spice_ignore=true}
C {res.sym} 850 -110 0 0 {name=R2
value=50k
footprint=1206
device=resistor
m=1
spice_ignore=true}
C {gnd.sym} 780 -80 0 0 {name=l13 lab=GND}
C {gnd.sym} 850 -80 0 0 {name=l14 lab=GND}
C {/foss/designs/DLL/2026/Cells/TOP.sym} 20 -70 0 0 {name=x17
}
C {sg13g2_IOPadAnalog.sym} -380 70 0 1 {name=x11
}
C {lab_pin.sym} -560 40 1 0 {name=p2 sig_type=std_logic lab=in_b}
C {sg13g2_IOPadAnalog.sym} -380 150 0 1 {name=x18
spice_ignore=true}
C {sg13g2_pr/bondpad.sym} -640 150 3 1 {name=X19
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} -560 120 1 0 {name=p12 sig_type=std_logic lab=in_c}
C {lab_pin.sym} 630 -280 1 0 {name=p13 sig_type=std_logic lab=out_a}
C {res.sym} 960 -180 3 0 {name=R1
value=10
footprint=1206
device=resistor
m=1
}
C {lab_pin.sym} 1100 -200 1 0 {name=p14 sig_type=std_logic lab=in_b}
C {vsource.sym} -800 -10 0 0 {name=Vin value="PULSE(0 1.2 0 20p 20p 1n 2n)"}
C {res.sym} 10 320 3 0 {name=R3
value=10
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 560 70 1 0 {name=p15 sig_type=std_logic lab=out_a}
C {lab_pin.sym} -150 -190 1 0 {name=p16 sig_type=std_logic lab=vin}
C {lab_pin.sym} 200 -180 1 0 {name=p17 sig_type=std_logic lab=vout}
C {lab_pin.sym} -40 20 0 0 {name=p19 sig_type=std_logic lab=vcont}
C {res.sym} -800 -100 2 0 {name=R4
value=10
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 820 -210 1 0 {name=p21 sig_type=std_logic lab=out_a}
C {code.sym} -1050 -20 0 0 {name=TRANSIENT1 only_toplevel=true
value="
.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
.control
 tran 2p 20n
 plot v(vin) v(vout)
 plot v(in_a) v(out_a)
 plot v(vout) v(out_a)
 plot v(vcont) 
 plot v(vout) v(vpb)
 *plot i(V1) 
.endc
"
}
C {sg13g2_IOPadAnalog.sym} 420 70 2 1 {name=x15
spice_ignore=true}
C {sg13g2_IOPadAnalog.sym} 420 -170 2 1 {name=x5
}
C {lab_pin.sym} -120 70 2 0 {name=p18 sig_type=std_logic lab=vpb}
